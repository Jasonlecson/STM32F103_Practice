# Keil uVision project F-RTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F-RTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CORE;..\OBJ;..\USER;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c
  group SYSTEM
    ../FreeRTOS/FreeRTOSv10.2.1_191129/FreeRTOS/Demo/CORTEX_STM32F103_Keil/: STM32F10x.s
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
